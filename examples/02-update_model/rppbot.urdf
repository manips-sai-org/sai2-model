Commit message: Removed load functions, code cleanup

File: examples/02-update_model/rppbot.urdf (robot description, URDF)
Before this commit: robot RPRBot, 4 links, 3 joints
Joints:
- joint j2: parent link1 -> link0; type revolute -> prismatic
